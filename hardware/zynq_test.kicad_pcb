# Repository cropinghigh/zynq_a9_mb

File README.md (part):

# A motherboard/test/dev board based on Xilinx 7Z010 and components from Antminer S9 control board

# !!!Before ordering the boards or any components, please read the entire readme, and all "Requirements" sections!!!

## Версия на русском: [README_RU.md](README_RU.md)

## Hardware:

### Features:
- Most expensive components can be salvaged from dirt cheap miner boards
- 6-layer pcb, moderately cheap to manufacture with JLCPCB, achieved by using Via In Pad technology
- Full 512MB two-chip DDR3 support
- Peripheral interfaces available on MIO pins: USB(Device/OTG), Gigabit ethernet, SD card(two switchable slots), eMMC+QSPI as boot media, I2C, UART, DS1307 RTC, XADC direct input
- Dedicated PL display header with 5 TMDS pairs, 5v/3.3v power lines, I2C and two GPIOs. Designed to be directly connectable to HDMI connector with simple extension board
- 10 matched length differential pairs available on PL_IO_A
- 22 matched length single ended CMOS lines available on PL_IO_B
- 44(+2 on PL_IO_A) general purpose CMOS lines available on PL_IO_C and PL_IO_D, effectively utilizing all 34 and 35 FPGA banks

PDF schematic is available at [hardware/schematic.pdf](hardware/schematic.pdf)

Component list(BOM) is available at [hardware/zynq_test_components_1.2.ods](hardware/zynq_test_components_1.2.ods). Values that are present on Antminer board, but not in enough amount for new board, marked with red. Values that are not present on Antminer board are marked with yellow. Any component on Antminer board from column "Antminer S9 Board Reference" could be soldered to any position from column "Reference" to the new board.

### To order from JLCPCB

Use file [hardware/gerbers/zynq_test.zip](hardware/gerbers/zynq_test.zip) and next PCB configuration:

- Layers: 6
- Dimensions: 99.5x100mm(auto derived from gerbers)
- PCB thickness: 1.2mm
- Material: FR4 TG135
- Surface finish: ENIG
- Outer copper weight: 1oz
- Inner copper weight: 0.5oz
- Stackup: JLC06121H-3313
- Impedance control: not required
- Via covering: Epoxy filled&Capped OR Copper paste filled&Capped (IMPORTANT!!!)
- Min via hole size/diameter: 0.3(0.4/0.45)mm
- PCB mark: Order number(specify position)

### Assembling requirements:

- PCBs themselves, ordered earlier
- A working Antminer S9 board
- Bunch of components that are not present on the miner board(in [hardware/zynq_test_components_1.2.ods](hardware/zynq_test_components_1.2.ods) marked with yellow - not present at all, and red - present, but not enough). Some components(U11,eMMC chip), can be changed to anything that is pin compatible to the specified part and has same electrical interface(so you can put bigger or smaller eMMC if needed). Also, if you don't need some of the functionality(e.g. eMMC, USB or RTC), you can just ignore the chip associated with it and all it's surroundings. Pay attention to the component footprints/cases when ordering - they are specified in separate column.
- Soldering iron and hot air rework station, tweezers, some container for the extra balls during reballing to fall into.
- Something as the bottom header for the boards - specialized tool is preferred, but just iron should work as well.
- Flux, suitable for SMD and BGA soldering(i use RMA218)
- Tools for reballing - special stand with spring holder for the chip, 0.8mm spacing;0.5mm ball stencil for Zynq and DDR chips, 0.5mm spacing;0.3mm ball stencil - in case you will need to reball the eMMC, bunch of 0.45mm and 0.3mm balls(yes, you want the 0.45mm ones for zynq and ddr, because they are much easier to work with when using cheap chinese 0.5mm stencils).
- Some basic electronic skills and debugging tools - multimeter, lab power supply. Oscilloscope would be very helpful.

### Assembling

0. Before disassembling the Antminer S9 board, first power it up with 12V DC and connect via UART to check if it's working, and more importantly, copy the MAC address to use later. To do that, wait until the linux kernel is loaded, and search for the lines        like 

    "Dumping data starting at 0x01060000 and ending at 0x01060001..."   and

    "[    4.367100] bcm54xx_config_init"

    Somewhere near them will be a string with board's MAC address. Or you can just look it up at the router's DHCP client list. Store that and keep for later. Power down the board and prepare for disassembly.

1. Removing the main components from the board.

    For that you will need a bottom heater(at least something like an iron) and hot air reflow station.

    First, desolder the C88 and C58 from the bottom side of the board(don't trow them out!), and remove the black rubber box as well as everything that lift the board significantly over the surface or could be melted.

    Then, turn the board back and put it on a bottom heater's surface. At this stage we will be desoldering all needed ICs and other big SMD components from it.

    ! Some boards lack the U6 SD card level converter. In that case, to get working SD cards on the new board, you will need to get that IC from other board, or buy a new chip.

    Finally, we can start the disassembly. Put a decent amount of flux around each of the components to be removed, and turn on the bottom heater. Wait until the PCB and big chips firmly heat up to around 150-160 dgr.C, when the flux starts to become liquid, but not vaporizing yet. After that, turn on the hot air, setting the temp to the value around 400-450 dgr.C (the PCB has very big thermal mass, so it's way easier to damage the ICs mechanically because of solder underheat, than by overheating them, but still - be careful). One by one, heat chips up until the solder is melted and take them off from the board. Pay special attention to BGA chips - balls under them should be *all* fluid enough so that entire chip is freely floating under the touch. It's *very* easy to damage it during the lift up, just bending the case too much with force.

    While the board is still hot, also carefully remove the RJ45 connector, adding leaded solder to it's pins beforehand.

    The one LSF0102DCTR at the bottom right is an extra IC, and you need to get it either from another board or buy a new one.

2. Preparing&reballing chips

    This is one of the hardest steps. Depending on result's quality, board can work strange or don't work at all.

    First, cover all removed ICs pads with a thin equal layer of leaded solder, cleaning extra when needed. Remove the flux.

    Additionaly, rub BGA ICs against paper(not sandpaper!!) put on solid metal surface, to further increase equality of pad heights.

    Apply a thin layer of flux to the BGA chip, spreading it evenly with a blade.

    Carefully put it on a stencil, matching pads precisely with holes in it.

    Start pouring balls on the chip, filling each hole with one. If some of them won't fall in immediately, you can manually put them in place using tweezers

    After that, slowly heat up stencil with chip with hot air at temp around 320-350drg.C. You will see as the balls start to melt and fall deeper in holes. If some of them stay afloat no matter the heat, you could very carefully poke them down with tweezers or other sharp tool. If they start to rapidly jump out on flux vapour, slow down the heating.

    Carefully remove IC from the stencil. If one or two balls are missing, you can gently place them manually with tweezers now. Add reasonable amount of flux and slowly heat the chip again with same hot air configuration. That step is needed to fix any misalignments of stencil and pads from before.

    After melting all balls, remove the heat and let it cool. You should get a surface with almost ideally equal height balls. Remove all flux from it.

    Clean the stencil with alcohol, and repeat the process for all BGA chips.

3. Soldering in chips and big SMD components

    Take the new PCB. Put it on preheater and heat to 150-160dgr.C. Cover all needed pads with thin equal layer of solder, using soldering iron(be careful not to scratch solder mask of the traces between BGA pads). Don't forget about second DDR chip on the other side.

    Then, let it cool down and clean all extra flux. Apply thin amount of flux on the pads with blade as when reballing BGA.

    Place all ICs, oscillators and big inductors on their respective pads EXCEPT L3,L4,L1,L5, accoring to key, as presice as possible. Place it on bottom heater again and heat up. Using hot air with temp around 350-400dgr.C, solder in everything, starting from BGA, until balls under them have fully melted.

    After that, additionally solder each side of each QFN chip using soldering iron, to make sure no pin floats in air. Check using microscope or at least magnifying glass.

    Finally, solder in other big inductors. And SOIC ICs, using soldering iron.

4. Assembling and testing power supplies

    It's important to do this prior to powering up entire board, because if power supplies are broken, they could easily kill FPGA or other expensive circuitry.

    You need to solder in all components under the "POWER REGULATORS" block in schematic diagram EXCEPT the FB14,FB13,FB10,FB11,FB12 to cut the power off the remaining board(open the board and schematic files at the same time, and select the entire block with mouse. You will see all required components highlighted in the board view window).

    Apply 5V to the J1 with lowest current limit possible, it should consume almost nothing(< 0.01A). D4 "5V_IN" and D3 "PWR_OK" should light on. If not, check the power good chain one by one(TP3 - 1V, TP6 - 1.5V, TP2 - 1.25V, TP8 - 2.1V, TP11 - 2.5V), likely the issue is that one of the QFN chips is soldered badly. Next, check the actual voltages on the ferrite bead points(FB14 - 1V, FB13 - 1.8V, FB10 - 1.5V, FB11 - 2.5V, FB12 - 3.3V). If all voltages are fine - the power supply is working correctly! Power off the board, solder in the remaining FB14,FB13,FB10,FB11 and FB12 and continue the building.

5. Completing the minimal SoC circuit

    To start up the Zynq and begin interacting with it, next components are required: "SOC POWER IN" block, "JTAG" block, "CLK" block, "FPGA STATUS LEDS" block, C89, SW1, R30, bootstrap part from "EMMC+BOOTSTRAP" block: R81,R82,R83,R84,R79,R80,R85,R86,SW2,SW3. (Also it's recommended to install Ethernet chip surrounding components to avoid burning it. I did not do that on the picture, and had to replace it later)

    After that, toggle BM switches to JTAG mode(BM1=0,BM2=0), connect USB Platform Cable to the board's JTAG connector, and power it up. Board should consume around 0.5A@5V at this point(later discovered that it was because of the dead Ethernet chip. Working board should use much less, around 0.17-0.22A), and yellow INIT_B LED should glow, turning off when reset button is pressed. Try connecting to it with xsdb utility(check Flashing section on how to do that). If it's detected - awesome, at least Zynq is powered properly and probably has all the important BGA pads soldered successfully! If not - first, check clock signal on TP19, then, try wiggling JTAG connector around, this helps sometimes. If that doesn't work - likely the chip is soldered badly. Put the board on preheater, CAREFULLY desolder the Zynq, reball it and try again, at some attempt it either should begin to work or you will eventually destroy the board's traces.

6. Bringing up the DDR

    Next step is soldering in all components related to DDR chips: just entire "DDR" block, and separate capacitors on the power line - C115,C116,C117,C118,C152,C154. Also you will need to solder in the UART converter to communicate with the board("UART" block, but choose only one of R151 and R155, selecting either 3.3V or 5V UART level).

    Hook up the JTAG and UART, and power on the board. Then, load the FSBL with xsdb(more on that in Flashing section). It should run, print the voltagtes and temperatures, and stop at "Boot mode is JTAG". If it says something about DDR fault, then likely the DDR chips soldering is bad. Remove them, reball and try again. At this point it's recommended run the memtest to check memory integrity and eye opening.

    Normal values for v1.1 board are no errors on entire 511MB test, 70-80% read eye and 60-70% write eye.

7. Finishing the assembly

    At this point, you just need to solder in everything that isn't there yet. Pay special attention to R158/R161 in I2C block(it's selecting either 5V or 3.3V I2C interface, never install both at the same time). You can connect an RTC battery or ionistor to BT1 terminals if you need to keep time, but remove D17, if it's not a rechargeable one. If you don't need some of the connectors, you can also don't solder them in, or do it later. R51/R52 are not required. ESD protection diodes are not neccesary but highly recommended(I just ordered them in a wrong case, so they don't present on pictures. Double check the component number and casing!)

    Now, you can check all the hardware on board using u-boot to make sure everything is soldered in correctly. And finally, start to flash the firmware to SPI flash and eMMC.

## Software:

### Building requirements

Basically, a Linux machine with tools to cross-compile software for armhf arch(arm-none-eabi- compiler, binutils, etc...). At some steps, working Vivado setup is also required. ARM qemu and special binfmt software is required to get the rootfs shell and configure it on the host machine, more on that in the corresponding step.

### Building from source

Replace -j4 with the number of cores your CPU have. Pre-built binaries for each stage are present in subsequent directories, so those steps are not neccesary.

1. Building fsbl

    In software/BOOTLOADER/fsbl/src run:

    `make BOARD=a9mb CC=arm-none-eabi-gcc CFLAGS=-DFSBL_DEBUG_INFO`

    (if you need to change peripheral config, for example PL clock frequency, first export platform from Vivado, then open .xsa file with archiver and copy ps7_init.c, ps7_init.h, ps7_init_gpl.c, ps7_init_gpl.h from it to software/BOOTLOADER/fsbl/misc/a9mb)

    The built fsbl executable is software/BOOTLOADER/fsbl/src/fsbl.elf

2. Building memtest

    If you need a memtest to check the DDR, build it in software/BOOTLOADER/memtest/src with:

    `make BOARD=a9mb CC=arm-none-eabi-gcc`

    Built executable will be software/BOOTLOADER/memtest/src/memtest.elf

3. Building u-boot

    In software/BOOTLOADER/u-boot run:

    `make CROSS_COMPILE=arm-none-eabi- ARCH=arm -j4 ind1r_a9_mb_defconfig`

    `make CROSS_COMPILE=arm-none-eabi- ARCH=arm -j4`

    (if you need to change main system device tree, it's located in software/BOOTLOADER/u-boot/arch/arm/dts/ind1r-a9-mb.dts, but it's recommended to change it using dtb overlays to get more flexibility)

    u-boot executable will be software/BOOTLOADER/u-boot/u-boot.elf

4. Making binary bootloader image

    In software/BOOTLOADER run:

    `/PATH/TO/Vivado/bin/bootgen -image bootimg.bif -o boot.bin -w on`

    Resulting boot.bin file is the ready SPI flash image.

5. Making bootscript

    In software/BOOTLOADER/bootscript execute

    `./mkbootscr.sh`

6. Prepare FPGA bitstream

    Put your .bit file from Vivado(either exported or from Platform.xsa) to software/BOOTLOADER/fpga_bs, and execute

    `./bit2bin.py -f INPUT.bit PL.bin`

7. Making DT overlays

    In software/KERNEL/dtb-overlays for each overlay you want(OVERLAY_NAME.dtso -> OVERLAY_NAME.dtbo) run:

    `./make_overlay.sh OVERLAY_NAME`

8. Building kernel

    In software/KERNEL/linux-xlnx run:

    `make CROSS_COMPILE=arm-none-eabi- ARCH=arm -j4 ind1r_a9_mb_defconfig`

    `make CROSS_COMPILE=arm-none-eabi- ARCH=arm -j4 zImage`

    If you also need to build modules:

    `make CROSS_COMPILE=arm-none-eabi- ARCH=arm -j4 modules`

    (to use them, you'll need to install them to the ROOTFS by running

    `sudo make CROSS_COMPILE=arm-none-eabi- ARCH=arm -j4 INSTALL_MOD_PATH=../../ROOTFS/fs modules_install`

    after rootfs is initialized and set up)

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
## KiCad design hardware/zynq_test.kicad_pcb

Schematic: zynq_test.kicad_sch, ZYNQ_A9_MB

Parts:
BT1: 3V; PinHeader_1x02_P2.54mm_Vertical
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C16, C17, C51, C52, C53, C54, C59, C60, C61, C64, C65, C66, C67, C68, C69, C70, C71, C72, C73, C75, C76, C79, C80, C81, C82, C88, C94, C96, C105, C112, C114, C144, C146, C148, C149, C157, C171, C179, C182, C183, C188, C190, C191, C198, C200, C201, C210, C211, C214, C216: 10u; C_0603_1608Metric
C11, C12, C13, C14, C15: 3.3n; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C18, C19, C20, C21, C23, C28, C29, C30, C31, C32, C33, C34, C35, C36, C37, C38, C39, C40, C41, C42, C43, C44, C45, C46, C47, C48, C49, C50, C55, C56, C57, C58, C62, C63, C87, C89, C90, C92, C93, C95, C97, C98, C99, C100, C101, C103, C104, C106, C107, C108, C109, C110, C111, C115, C116, C117, C118, C119, C120, C121, C122, C123, C124, C125, C126, C127, C128, C129, C130, C131, C132, C133, C134, C135, C136, C137, C138, C139, C141, C143, C145, C147, C150, C151, C152, C153, C154, C156, C158, C159, C160, C163, C164, C165, C166, C167, C168, C169, C170, C172, C173, C174, C175, C176, C177, C178, C180, C181, C184, C185, C187, C189, C192, C193, C194, C195, C196, C197, C202, C203, C204, C205, C206, C207, C208, C209, C212, C213, C215, C217: 0.47u; C_0603_1608Metric
C22, C24, C25, C26, C27: 22u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C74, C77, C78, C83, C84, C85, C86, C91, C102, C113, C140, C142, C155, C199: 100u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C161, C162: 12p; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C186: 1n; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
D1: ZMM7V5; D_MiniMELF_Handsoldering
D2, D17, D21: 1N5822; D_SMA
D3: GREEN PWR_OK; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D4: GREEN 5V; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D5: GREEN 2V5; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D6: GREEN 3V3; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D7: YELLOW INIT_B; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D8: GREEN DONE; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D9: GREEN IO1; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D10: RED IO2; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D11: BLUE IO3; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D12: YELLOW IO4; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D13, D14, D15, D22: CDDFN10-0524P; Diodes_UDFN-10_1.0x2.5mm_P0.5mm
D16: BLUE ETH_LED1; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D18: YELLOW MIO0; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D19: GREEN MIO7; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D20: RED MIO8; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D23: RED USB OVERLOAD; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
F1: PWRIN_CONN; Fuse_1206_3216Metric
F2: PWR_USB; Fuse_1206_3216Metric
FB1, FB2, FB3, FB4, FB5, FB6, FB10, FB11, FB12, FB13, FB14, FB18: 100R; L_1206_3216Metric_Pad1.42x1.75mm_HandSolder
FB7, FB8, FB9, FB15, FB16, FB17: 100R/3A; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder
H1: HOLE1; MountingHole_3.2mm_M3_DIN965_Pad
H2: HOLE2; MountingHole_3.2mm_M3_DIN965_Pad
H3: HOLE3; MountingHole_3.2mm_M3_DIN965_Pad
H4: HOLE4; MountingHole_3.2mm_M3_DIN965_Pad
J1: PWRIN; BarrelJack_Horizontal
J2: JTAG_SMALL; PinHeader_2x07_P2.00mm_Vertical
J3: PL_IO_A; PinHeader_2x14_P2.00mm_Vertical
J4: PL_IO_B; PinHeader_2x14_P2.00mm_Vertical
J5: PL_IO_C; PinHeader_2x14_P2.00mm_Vertical
J6: PL_IO_D; PinHeader_2x14_P2.00mm_Vertical
J7: RJ45; RJ45_Amphenol_RJHSE538X
J8: DISPLAY; PinHeader_2x11_P2.00mm_Vertical
J9: ADC; PinHeader_1x02_P2.54mm_Vertical
J10: UART; PinHeader_1x03_P2.54mm_Vertical
J11: I2C; PinHeader_1x03_P2.54mm_Vertical
J12, J13: MicroSD; microSD_ali
J14: USB_C; USB_C_Receptacle_HCTL_HC-TYPE-C-16P-01A
L1, L2, L3, L4: 1u; L_APV_ANR3010
L5: 2.2u; L_APV_ANR8040
R1, R33, R34, R37, R38, R39, R41, R42, R43, R44, R50, R90, R93, R103, R105, R138, R143, R146, R147, R150: 4.7k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R2: 17.4k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R3, R5, R7, R79, R80, R81, R82, R83, R84, R85, R86, R87, R88, R94: 20k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R4: 24.9k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R6, R46: 42.2k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R8, R29: 61.9k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R9, R11: 19.6k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R10, R17, R19, R21, R23, R25: 4.99k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R12, R13, R14, R15, R51, R52, R113, R124, R125, R126, R151, R155, R158, R161: 0; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R16, R18, R20, R30, R35, R40, R92, R100, R101, R102, R140, R141, R142, R144, R145, R156, R157, R159, R160: 1k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R22: 1.58k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R24, R77, R78, R104, R106, R127, R128, R129, R130, R131, R132, R133, R134, R135, R136, R149: 240; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R26, R27, R47: 140k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R28, R107: 15k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R31, R32, R137, R154: 8k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R36, R152, R153: 200k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R45, R53, R54, R55, R56, R57, R59, R60, R61, R62, R63, R64, R65, R66, R67, R68, R69, R70, R71, R72, R73, R74, R75, R76, R89, R95, R96, R97, R98, R112, R114, R115, R116, R117, R118, R119, R120, R121, R122, R123, R139: 40; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R48, R49, R58, R108, R109, R110, R111: 80; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R91, R148, R162, R163: 820; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R99: 1.24k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
SW1: POR; SW_SPST_Omron_B3F-315x_Angled
SW2: BOOT_MODE_1; SW_SPDT_PCM12
SW3: BOOT_MODE_2; SW_SPDT_PCM12
SW4: SD_SEL; SW_SPDT_PCM12
TP1: 5V; TestPoint_Pad_1.0x1.0mm
TP2: 1V5_PG; TestPoint_Pad_1.0x1.0mm
TP3: 1V_PG; TestPoint_Pad_1.0x1.0mm
TP4: 1V5; TestPoint_Pad_1.0x1.0mm
TP5: 1V8; TestPoint_Pad_1.0x1.0mm
TP6: 1V8_PG; TestPoint_Pad_1.0x1.0mm
TP7: 2V5; TestPoint_Pad_1.0x1.0mm
TP8: 2V5_PG; TestPoint_Pad_1.0x1.0mm
TP9: 3V3; TestPoint_Pad_1.0x1.0mm
TP10: 1V; TestPoint_Pad_1.0x1.0mm
TP11: 3V3_PG; TestPoint_Pad_1.0x1.0mm
TP12, TP13, TP17, TP21, TP23, TP36, TP37, TP40, TP46, TP48: GND; TestPoint_Pad_1.0x1.0mm
TP14: POR; TestPoint_Pad_1.0x1.0mm
TP15: DDRT_PG; TestPoint_Pad_1.0x1.0mm
TP16: DDR_VREF; TestPoint_Pad_1.0x1.0mm
TP18: SRST; TestPoint_Pad_1.0x1.0mm
TP19: CLK; TestPoint_Pad_1.0x1.0mm
TP20: DDR_VTT; TestPoint_Pad_1.0x1.0mm
TP22: EMMC_CMD; TestPoint_Pad_1.0x1.0mm
TP24: EMMC_CLK; TestPoint_Pad_1.0x1.0mm
TP25: QSPI_CS; TestPoint_Pad_1.0x1.0mm
TP26: EMMC_DAT0; TestPoint_Pad_1.0x1.0mm
TP27: EMMC_DAT1; TestPoint_Pad_1.0x1.0mm
TP28: QSPI_SCK; TestPoint_Pad_1.0x1.0mm
TP29: EMMC_DAT2; TestPoint_Pad_1.0x1.0mm
TP30: EMMC_DAT3; TestPoint_Pad_1.0x1.0mm
TP31: EMMC_RST; TestPoint_Pad_1.0x1.0mm
TP32: QSPI_IO0; TestPoint_Pad_1.0x1.0mm
TP33: QSPI_IO1; TestPoint_Pad_1.0x1.0mm
TP34: QSPI_WP; TestPoint_Pad_1.0x1.0mm
TP35: QSPI_HOLD; TestPoint_Pad_1.0x1.0mm
TP38: ETH_CLK; TestPoint_Pad_1.0x1.0mm
TP39: SD_CLK; TestPoint_Pad_1.0x1.0mm
TP41: SD_CMD; TestPoint_Pad_1.0x1.0mm
TP42: SD_DAT3; TestPoint_Pad_1.0x1.0mm
TP43: SD_DAT2; TestPoint_Pad_1.0x1.0mm
TP44: SD_DAT1; TestPoint_Pad_1.0x1.0mm
TP45: SD_DAT0; TestPoint_Pad_1.0x1.0mm
TP47: SD_CD; TestPoint_Pad_1.0x1.0mm
TP49: USB_RST; TestPoint_Pad_1.0x1.0mm
TP50: USBCLK; TestPoint_Pad_1.0x1.0mm
TP51: USB_VBUS; TestPoint_Pad_1.0x1.0mm
TR1: G2405CG; Transformer_Ethernet_Bourns_PT61020EL
U1, U2, U3, U4, U5: TLV62130RGTR; QFN50P300X300X100-17N
U6: TPS51200DRC; VSON-10-1EP_3x3mm_P0.5mm_EP1.65x2.4mm
U7, U16, U17: LSF0102DCTR; SOP65P400X130-8N; PARTREV J
U8, U9: nt5cc128m16ip-di; BGA96C80P6X16_800X1400X120; PARTREV S
U10: XC7Z010-1CLG400C; CLG400_XIL-L
U11: SDIN7DP2-8G; MICRON_EMMC_153-12
U12: MX25L1606E; SOIC-8_5.3x5.3mm_P1.27mm
U13: B50612; Infineon_MLPQ-48-1EP_7x7mm_P0.5mm_EP5.15x5.15mm
U14: USB3315; QFN-24-1EP_4x4mm_P0.5mm_EP2.5x2.5mm
U15: TXS02612RTW; WQFN-24-1EP_4x4mm_P0.5mm_EP2.45x2.45mm_ThermalVias
U18: DS1307Z+; SOIC-8_3.9x4.9mm_P1.27mm
U19: LM3525-H; SOIC-8_3.9x4.9mm_P1.27mm
Y1: 33.333M; Oscillator_SMD_EuroQuartz_XO32-4Pin_3.2x2.5mm
Y2: 25M; Oscillator_SMD_EuroQuartz_XO32-4Pin_3.2x2.5mm
Y3: 32.768k; Crystal_C38-LF_D3.0mm_L8.0mm_Vertical
Y4: 24M; Oscillator_SMD_EuroQuartz_XO53-4Pin_5.0x3.2mm

Connections:
+1V0: C38.1, C43.1, C44.1, C48.1, C56.1, C57.1, C61.1, C70.1, C71.1, C76.1, C83.1, C84.1, FB14.1, TP10.1, U10.G7 (VCCPINT), U10.G11 (VCCBRAM), U10.G13 (VCCINT), U10.H10 (VCCBRAM), U10.H12 (VCCINT), U10.J7 (VCCPINT), U10.J13 (VCCINT), U10.K12 (VCCINT), U10.L7 (VCCPINT), U10.L13 (VCCINT), U10.M12 (VCCINT), U10.N7 (VCCPINT), U10.N13 (VCCINT), U10.P8 (VCCPINT), U10.P12 (VCCINT), U10.R7 (VCCPINT), U10.R13 (VCCINT)
+1V5: C33.1, C45.1, C58.1, C72.1, C85.1, C87.1, C102.1, C105.1, C109.1, C110.1, C115.1, C116.1, C117.1, C118.1, C121.1, C122.1, C123.1, C125.1, C126.1, C127.1, C128.1, C129.1, C130.1, C131.1, C132.1, C133.1, C134.1, C135.1, C136.1, C137.1, C138.1, C139.1, C140.1, C141.1, C142.1, C143.1, C144.1, C145.1, C146.1, C147.1, C148.1, C149.1, C152.1, C154.1, FB10.1, R31.2, R48.2, TP4.1, U6.2 (VLDOIN), U8.A1 (VDDQ), U8.A8 (VDDQ), U8.B2 (VDD), U8.C1 (VDDQ), U8.C9 (VDDQ), U8.D2 (VDDQ), U8.D9 (VDD), U8.E9 (VDDQ), U8.F1 (VDDQ), U8.G7 (VDD), U8.H2 (VDDQ), U8.H9 (VDDQ), U8.K2 (VDD), U8.K8 (VDD), U8.N1 (VDD), U8.N9 (VDD), U8.R1 (VDD), U8.R9 (VDD), U9.A1 (VDDQ), U9.A8 (VDDQ), U9.B2 (VDD), U9.C1 (VDDQ), U9.C9 (VDDQ), U9.D2 (VDDQ), U9.D9 (VDD), U9.E9 (VDDQ), U9.F1 (VDDQ), U9.G7 (VDD), U9.H2 (VDDQ), U9.H9 (VDDQ), U9.K2 (VDD), U9.K8 (VDD), U9.N1 (VDD), U9.N9 (VDD), U9.R1 (VDD), U9.R9 (VDD), U10.A3 (VCCO_DDR_502), U10.D2 (VCCO_DDR_502), U10.E5 (VCCO_DDR_502), U10.G1 (VCCO_DDR_502), U10.H4 (VCCO_DDR_502), U10.L3 (VCCO_DDR_502), U10.P2 (VCCO_DDR_502)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
+1V8: C46.1, C47.1, C59.1, C60.1, C73.1, C74.1, C191.1, C192.1, C193.1, FB8.2, FB9.2, FB13.1, TP5.1, U10.F8 (VCCPAUX), U10.G9 (VCCPAUX), U10.H8 (VCCPAUX), U10.J11 (VCCAUX), U10.K8 (VCCPAUX), U10.L11 (VCCAUX), U10.M8 (VCCPAUX), U10.N9 (VCCAUX), U10.N11 (VCCAUX), U10.P10 (VCCAUX), U10.R9 (VCCAUX), U14.21 (VDD1.8)
+2V5: C49.1, C64.1, C77.1, C93.1, C170.1, C172.1, C176.1, C194.1, C195.1, C196.1, C197.1, C198.1, C200.1, D16.2 (A), FB11.1, J7.10, R28.2, R35.1, R100.1, R101.1, R138.1, R140.1, R141.1, R144.1, R145.1, SW4.3 (C), TP7.1, U7.2 (VREF_A), U10.A13 (VCCO_MIO1_501), U10.B16 (VCCO_MIO1_501), U10.D12 (VCCO_MIO1_501), U10.E15 (VCCO_MIO1_501), U13.1 (OVDD), U13.29 (OVDD_RGMII1), U13.34 (OVDD_RGMII2), U14.17 (VDDIO), U15.5 (V_{CCA}), U16.2 (VREF_A), U17.2 (VREF_A)
+3V3: C18.1, C19.1, C20.1, C21.1, C28.1, C29.1, C30.1, C31.1, C34.1, C35.1, C36.1, C37.1, C39.1, C40.1, C41.1, C42.1, C50.1, C51.1, C52.1, C53.1, C54.1, C65.1, C66.1, C67.1, C68.1, C69.1, C78.1, C79.1, C80.1, C81.1, C82.1, C86.1, C88.1, C90.1, C91.1, C92.1, C94.1, C95.1, C106.1, C153.1, C155.1, C156.1, C157.1, C158.1, C159.1, C160.1, C169.1, C171.1, C189.1, C190.1, C199.1, C201.1, C202.1, C203.1, C204.1, C205.1, C208.1, C209.1, C210.1, C211.1, C213.1, D23.2 (A), FB12.1, FB15.2, J2.2, J3.1, J3.27, J4.1, J4.27, J5.1, J5.27, J6.1, J6.27, J8.19, J12.4 (VDD), J13.4 (VDD), R29.2, R33.2, R34.2, R36.1, R37.1, R38.1, R39.1, R40.1, R41.1, R42.1, R43.1, R44.1, R87.2, R88.1, R94.2, R127.1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
+5V: C16.1, C17.1, C23.1, C32.1, C212.1, C214.1, C215.1, D1.1 (K), D2.1 (K), D21.1 (K), FB1.2, FB2.2, FB3.2, FB4.2, FB5.2, FB6.1, R27.2, R112.1, R155.1, R161.1, TP1.1, U18.8 (VCC), U19.7 (IN)
/DDR_A0: R60.1, U8.N3 (A0), U9.N3 (A0), U10.N2 (PS_DDR_A0_502)
/DDR_A1: R61.1, U8.P7 (A1), U9.P7 (A1), U10.K2 (PS_DDR_A1_502)
/DDR_A2: R62.1, U8.P3 (A2), U9.P3 (A2), U10.M3 (PS_DDR_A2_502)
/DDR_A3: R63.1, U8.N2 (A3), U9.N2 (A3), U10.K3 (PS_DDR_A3_502)
/DDR_A4: R64.1, U8.P8 (A4), U9.P8 (A4), U10.M4 (PS_DDR_A4_502)
/DDR_A5: R65.1, U8.P2 (A5), U9.P2 (A5), U10.L1 (PS_DDR_A5_502)
/DDR_A6: R66.1, U8.R8 (A6), U9.R8 (A6), U10.L4 (PS_DDR_A6_502)
/DDR_A7: R67.1, U8.R2 (A7), U9.R2 (A7), U10.K4 (PS_DDR_A7_502)
/DDR_A8: R68.1, U8.T8 (A8), U9.T8 (A8), U10.K1 (PS_DDR_A8_502)
/DDR_A9: R69.1, U8.R3 (A9), U9.R3 (A9), U10.J4 (PS_DDR_A9_502)
/DDR_A10: R70.1, U8.L7 (A10/AP), U9.L7 (A10/AP), U10.F5 (PS_DDR_A10_502)
/DDR_A11: R71.1, U8.R7 (A11), U9.R7 (A11), U10.G4 (PS_DDR_A11_502)
/DDR_A12: R72.1, U8.N7 (A12/~BC), U9.N7 (A12/~BC), U10.E4 (PS_DDR_A12_502)
/DDR_A13: R73.1, U8.T3 (A13), U9.T3 (A13), U10.D4 (PS_DDR_A13_502)
/DDR_A14: U10.F4 (PS_DDR_A14_502)
/DDR_BA0: R74.1, U8.M2 (BA0), U9.M2 (BA0), U10.L5 (PS_DDR_BA0_502)
/DDR_BA1: R75.1, U8.N8 (BA1), U9.N8 (BA1), U10.R4 (PS_DDR_BA1_502)
/DDR_BA2: R76.1, U8.M3 (BA2), U9.M3 (BA2), U10.J5 (PS_DDR_BA2_502)
/DDR_CASB: R55.1, U8.K3 (~CAS), U9.K3 (~CAS), U10.P5 (PS_DDR_CAS_B_502)
/DDR_CKE: R57.1, U8.K9 (CKE), U9.K9 (CKE), U10.N3 (PS_DDR_CKE_502)
/DDR_CKN: R58.2, U8.K7 (~CK), U9.K7 (~CK), U10.M2 (PS_DDR_CKN_502)
/DDR_CKP: R58.1, U8.J7 (CK), U9.J7 (CK), U10.L2 (PS_DDR_CKP_502)
/DDR_CSB: R53.1, U8.L2 (~CS), U9.L2 (~CS), U10.N1 (PS_DDR_CS_B_502)
/DDR_DM0: U8.E7 (LDM), U10.A1 (PS_DDR_DM0_502)
/DDR_DM1: U8.D3 (UDM), U10.F1 (PS_DDR_DM1_502)
/DDR_DM2: U9.E7 (LDM), U10.T1 (PS_DDR_DM2_502)
/DDR_DM3: U9.D3 (UDM), U10.Y1 (PS_DDR_DM3_502)
/DDR_DQ0: U8.F7 (DQ1), U10.C3 (PS_DDR_DQ0_502)
/DDR_DQ1: U8.H7 (DQ7), U10.B3 (PS_DDR_DQ1_502)
/DDR_DQ2: U8.E3 (DQ0), U10.A2 (PS_DDR_DQ2_502)
/DDR_DQ3: U8.H8 (DQ5), U10.A4 (PS_DDR_DQ3_502)
/DDR_DQ4: U8.F2 (DQ2), U10.D3 (PS_DDR_DQ4_502)
/DDR_DQ5: U8.H3 (DQ4), U10.D1 (PS_DDR_DQ5_502)
/DDR_DQ6: U8.F8 (DQ3), U10.C1 (PS_DDR_DQ6_502)
/DDR_DQ7: U8.G2 (DQ6), U10.E1 (PS_DDR_DQ7_502)
/DDR_DQ8: U8.C8 (DQ10), U10.E2 (PS_DDR_DQ8_502)
/DDR_DQ9: U8.A2 (DQ13), U10.E3 (PS_DDR_DQ9_502)
/DDR_DQ10: U8.C2 (DQ11), U10.G3 (PS_DDR_DQ10_502)
/DDR_DQ11: U8.A3 (DQ15), U10.H3 (PS_DDR_DQ11_502)
/DDR_DQ12: U8.A7 (DQ12), U10.J3 (PS_DDR_DQ12_502)
/DDR_DQ13: U8.C3 (DQ9), U10.H2 (PS_DDR_DQ13_502)
/DDR_DQ14: U8.D7 (DQ8), U10.H1 (PS_DDR_DQ14_502)
/DDR_DQ15: U8.B8 (DQ14), U10.J1 (PS_DDR_DQ15_502)
/DDR_DQ16: U9.H8 (DQ5), U10.P1 (PS_DDR_DQ16_502)
/DDR_DQ17: U9.F8 (DQ3), U10.P3 (PS_DDR_DQ17_502)
/DDR_DQ18: U9.H3 (DQ4), U10.R3 (PS_DDR_DQ18_502)
/DDR_DQ19: U9.G2 (DQ6), U10.R1 (PS_DDR_DQ19_502)
/DDR_DQ20: U9.F7 (DQ1), U10.T4 (PS_DDR_DQ20_502)
/DDR_DQ21: U9.H7 (DQ7), U10.U4 (PS_DDR_DQ21_502)
/DDR_DQ22: U9.E3 (DQ0), U10.U2 (PS_DDR_DQ22_502)
/DDR_DQ23: U9.F2 (DQ2), U10.U3 (PS_DDR_DQ23_502)
/DDR_DQ24: U9.C8 (DQ10), U10.V1 (PS_DDR_DQ24_502)
/DDR_DQ25: U9.C2 (DQ11), U10.Y3 (PS_DDR_DQ25_502)
/DDR_DQ26: U9.D7 (DQ8), U10.W1 (PS_DDR_DQ26_502)
/DDR_DQ27: U9.A3 (DQ15), U10.Y4 (PS_DDR_DQ27_502)
/DDR_DQ28: U9.C3 (DQ9), U10.Y2 (PS_DDR_DQ28_502)
/DDR_DQ29: U9.A2 (DQ13), U10.W3 (PS_DDR_DQ29_502)
/DDR_DQ30: U9.B8 (DQ14), U10.V2 (PS_DDR_DQ30_502)
/DDR_DQ31: U9.A7 (DQ12), U10.V3 (PS_DDR_DQ31_502)
/DDR_DQSN0: U8.G3 (~LDQS), U10.B2 (PS_DDR_DQS_N0_502)
/DDR_DQSN1: U8.B7 (~UDQS), U10.F2 (PS_DDR_DQS_N1_502)
/DDR_DQSN2: U9.G3 (~LDQS), U10.T2 (PS_DDR_DQS_N2_502)
/DDR_DQSN3: U9.B7 (~UDQS), U10.W4 (PS_DDR_DQS_N3_502)
/DDR_DQSP0: U8.F3 (LDQS), U10.C2 (PS_DDR_DQS_P0_502)
/DDR_DQSP1: U8.C7 (UDQS), U10.G2 (PS_DDR_DQS_P1_502)
/DDR_DQSP2: U9.F3 (LDQS), U10.R2 (PS_DDR_DQS_P2_502)
/DDR_DQSP3: U9.C7 (UDQS), U10.W5 (PS_DDR_DQS_P3_502)
/DDR_DRSTB: R50.1, U8.T2 (~RESET), U9.T2 (~RESET), U10.B4 (PS_DDR_DRST_B_502)
/DDR_ODT: R59.1, U8.K1 (ODT), U9.K1 (ODT), U10.N5 (PS_DDR_ODT_502)
/DDR_POWER_REG_REFIN: C96.1, C99.1, R31.1, R32.2, U6.1 (REFIN)
/DDR_POWER_REG_VTT: C97.1, C98.1, C100.1, C101.1, C103.1, C104.1, C107.1, C108.1, C111.1, C112.1, C113.1, R53.2, R54.2, R55.2, R56.2, R57.2, R59.2, R60.2, R61.2, R62.2, R63.2, R64.2, R65.2, R66.2, R67.2, R68.2, R69.2, R70.2, R71.2, R72.2, R73.2, R74.2, R75.2, R76.2, TP20.1, U6.3 (VO), U6.5 (VOSNS)
/DDR_RASB: R54.1, U8.J3 (~RAS), U9.J3 (~RAS), U10.P4 (PS_DDR_RAS_B_502)
/DDR_VREF: C114.1, C119.1, C120.1, C124.1, C150.1, TP16.1, U6.6 (REFOUT), U8.H1 (VREFDQ), U8.M8 (VREFCA), U9.H1 (VREFDQ), U9.M8 (VREFCA), U10.H6 (PS_DDR_VREF0_502), U10.P6 (PS_DDR_VREF1_502)
/DDR_VRN: R48.1, U10.G5 (PS_DDR_VRN_502)
/DDR_VRP: R49.1, U10.H5 (PS_DDR_VRP_502)
/DDR_WEB: R56.1, U8.L3 (~WE), U9.L3 (~WE), U10.M5 (PS_DDR_WE_B_502)
/DDR_ZQ_1: R77.2, U8.L8 (ZQ)
/DDR_ZQ_2: R78.2, U9.L8 (ZQ)
/DISP_L0+: J8.3, R114.2, R133.1
/DISP_L0-: J8.5, R115.2, R134.1
/DISP_L1+: J8.7, R116.2, R135.1
/DISP_L1-: J8.9, R117.2, R136.1
/DISP_L2+: J8.11, R118.2, R127.2
/DISP_L2-: J8.13, R119.2, R128.2
/DISP_L3+: J8.15, R120.2, R129.2
/DISP_L3-: J8.17, R121.2, R130.2
/DISP_L4+: J8.18, R122.2, R131.2
/DISP_L4-: J8.16, R123.2, R132.2
/ETHT_TRD0+: J7.1, TR1.23 (MX1+)
/ETHT_TRD0-: J7.2, TR1.22 (MX1-)
/ETHT_TRD1+: J7.3, TR1.20 (MX2+)
/ETHT_TRD1-: J7.6, TR1.19 (MX2-)
/ETHT_TRD2+: J7.4, TR1.17 (MX3+)
/ETHT_TRD2-: J7.5, TR1.16 (MX3-)
/ETHT_TRD3+: J7.7, TR1.14 (MX4+)
/ETHT_TRD3-: J7.8, TR1.13 (MX4-)
/ETH_TRD0+: TR1.2 (TD1+), U13.14 (TRD0+)
/ETH_TRD0-: TR1.3 (TD1-), U13.15 (TRD0-)
/ETH_TRD1+: TR1.5 (TD2+), U13.18 (TRD1+)
/ETH_TRD1-: TR1.6 (TD2-), U13.17 (TRD1-)
/ETH_TRD2+: TR1.8 (TD3+), U13.20 (TRD2+)
/ETH_TRD2-: TR1.9 (TD3-), U13.21 (TRD2-)
/ETH_TRD3+: TR1.11 (TD4+), U13.24 (TRD3+)
/ETH_TRD3-: TR1.12 (TD4-), U13.23 (TRD3-)
/I2C_SCL: D15.4 (D3), D15.7 (D3), J8.8, J11.3, R157.2, U17.6 (B1), U18.6 (SCL)
/I2C_SDA: D15.5 (D4), D15.6 (D4), J8.6, J11.1, R160.2, U17.5 (B2), U18.5 (SDA)
/IO_35_L7N: J3.15, U10.M20 (IO_L7N_T1_AD2N_35)
/IO_35_L7P: J3.16, U10.M19 (IO_L7P_T1_AD2P_35)
/IO_35_L10N: J3.21, U10.J19 (IO_L10N_T1_AD11N_35)
/IO_35_L10P: J3.22, U10.K19 (IO_L10P_T1_AD11P_35)
/IO_35_L17N: J3.23, U10.H20 (IO_L17N_T2_AD5N_35)
/IO_35_L17P: J3.24, U10.J20 (IO_L17P_T2_AD5P_35)
/IO_A20: J6.24, U10.A20 (IO_L2N_T0_AD8N_35)
/IO_B19: J5.14, U10.B19 (IO_L2P_T0_AD8P_35)
/IO_B20: J5.3, U10.B20 (IO_L1N_T0_AD0N_35)
/IO_C20: J5.4, U10.C20 (IO_L1P_T0_AD0P_35)
/IO_D18: J5.5, U10.D18 (IO_L3N_T0_DQS_AD1N_35)
/IO_D19: J5.6, U10.D19 (IO_L4P_T0_35)
/IO_D20: J5.13, U10.D20 (IO_L4N_T0_35)
/IO_E17: J6.3, U10.E17 (IO_L3P_T0_DQS_AD1P_35)
/IO_E18: J5.7, U10.E18 (IO_L5P_T0_AD9P_35)
/IO_E19: J5.8, U10.E19 (IO_L5N_T0_AD9N_35)
/IO_F16: J6.4, U10.F16 (IO_L6P_T0_35)
/IO_F17: J6.6, U10.F17 (IO_L6N_T0_VREF_35)
/IO_F19: J5.16, U10.F19 (IO_L15P_T2_DQS_AD12P_35)
/IO_F20: J5.15, U10.F20 (IO_L15N_T2_DQS_AD12N_35)
/IO_G14: J6.8, U10.G14 (IO_0_35)
/IO_G15: J6.7, U10.G15 (IO_L19N_T3_VREF_35)
/IO_G17: J6.9, U10.G17 (IO_L16P_T2_35)
/IO_G18: J6.10, U10.G18 (IO_L16N_T2_35)
/IO_H15: J5.9, U10.H15 (IO_L19P_T3_35)
/IO_H16: J5.12, U10.H16 (IO_L13P_T2_MRCC_35)
/IO_H17: J6.11, U10.H17 (IO_L13N_T2_MRCC_35)
/IO_H18: J6.12, U10.H18 (IO_L14N_T2_AD4N_SRCC_35)
/IO_J14: J5.18, U10.J14 (IO_L20N_T3_AD6N_35)
/IO_J15: J5.11, U10.J15 (IO_25_35)
/IO_J16: J6.13, U10.J16 (IO_L24N_T3_AD15N_35)
/IO_J18: J6.25, U10.J18 (IO_L14P_T2_AD4P_SRCC_35)
/IO_K14: J5.17, U10.K14 (IO_L20P_T3_AD6P_35)
/IO_K16: J6.15, U10.K16 (IO_L24P_T3_AD15P_35)
/IO_K17: J6.16, U10.K17 (IO_L12P_T1_MRCC_35)
/IO_K18: J4.25, U10.K18 (IO_L12N_T1_MRCC_35)
/IO_L4N: D15.2 (D2), D15.9 (D2), R123.1, U10.W13 (IO_L4N_T0_34)
/IO_L4P: D15.1 (D1), D15.10 (D1), R122.1, U10.V12 (IO_L4P_T0_34)
/IO_L7N: D13.5 (D4), D13.6 (D4), R117.1, U10.Y17 (IO_L7N_T1_34)
/IO_L7P: D13.4 (D3), D13.7 (D3), R116.1, U10.Y16 (IO_L7P_T1_34)
/IO_L8N: D14.5 (D4), D14.6 (D4), R121.1, U10.Y14 (IO_L8N_T1_34)
/IO_L8P: D14.4 (D3), D14.7 (D3), R120.1, U10.W14 (IO_L8P_T1_34)
/IO_L9N: J3.17, U10.L20 (IO_L9N_T1_DQS_AD3N_35)
/IO_L9P: J3.18, U10.L19 (IO_L9P_T1_DQS_AD3P_35)
/IO_L10N: D14.2 (D2), D14.9 (D2), R119.1, U10.W15 (IO_L10N_T1_34)
/IO_L10P: D14.1 (D1), D14.10 (D1), R118.1, U10.V15 (IO_L10P_T1_34)
/IO_L12N: J3.5, U10.U19 (IO_L12N_T1_MRCC_34)
/IO_L12P: J3.6, U10.U18 (IO_L12P_T1_MRCC_34)
/IO_L13N: J3.11, U10.P19 (IO_L13N_T2_MRCC_34)
/IO_L13P: J3.12, U10.N18 (IO_L13P_T2_MRCC_34)
/IO_L14: J6.20, U10.L14 (IO_L22P_T3_AD7P_35)
/IO_L14N: J3.13, U10.P20 (IO_L14N_T2_SRCC_34)
/IO_L14P: J3.14, U10.N20 (IO_L14P_T2_SRCC_34)
/IO_L15: J6.17, U10.L15 (IO_L22N_T3_AD7N_35)
/IO_L15N: J3.7, U10.U20 (IO_L15N_T2_DQS_34)
/IO_L15P: J3.8, U10.T20 (IO_L15P_T2_DQS_34)
/IO_L16: J6.18, U10.L16 (IO_L11P_T1_SRCC_35)
/IO_L17: J4.26, U10.L17 (IO_L11N_T1_SRCC_35)
/IO_L17N: D13.2 (D2), D13.9 (D2), R115.1, U10.Y19 (IO_L17N_T2_34)
/IO_L17P: D13.1 (D1), D13.10 (D1), R114.1, U10.Y18 (IO_L17P_T2_34)
/IO_L18N: J3.25, U10.G20 (IO_L18N_T2_AD13N_35)
/IO_L18P: J3.26, U10.G19 (IO_L18P_T2_AD13P_35)
/IO_L22N: J3.3, U10.W19 (IO_L22N_T3_34)
/IO_L22P: J3.4, U10.W18 (IO_L22P_T3_34)
/IO_M14: J6.22, U10.M14 (IO_L23P_T3_35)
/IO_M15: J5.19, U10.M15 (IO_L23N_T3_35)
/IO_M17: J4.23, U10.M17 (IO_L8P_T1_AD10P_35)
/IO_M18: J4.24, U10.M18 (IO_L8N_T1_AD10N_35)
/IO_N15: J5.22, U10.N15 (IO_L21P_T3_DQS_AD14P_35)
/IO_N16: J6.19, U10.N16 (IO_L21N_T3_DQS_AD14N_35)
/IO_N17: J4.21, U10.N17 (IO_L23P_T3_34)
/IO_P14: J5.24, R91.2, U10.P14 (IO_L6P_T0_34)
/IO_P15: J5.21, U10.P15 (IO_L24P_T3_34)
/IO_P16: J4.22, U10.P16 (IO_L24N_T3_34)
/IO_P18: J3.19, U10.P18 (IO_L23N_T3_34)
/IO_R14: J5.23, R90.2, U10.R14 (IO_L6N_T0_VREF_34)
/IO_R16: J4.19, U10.R16 (IO_L19P_T3_34)
/IO_R17: J4.17, U10.R17 (IO_L19N_T3_VREF_34)
/IO_R18: J4.15, U10.R18 (IO_L20N_T3_34)
/IO_R19: J4.18, U10.R19 (IO_0_34)
/IO_T10: J6.23, U10.T10 (IO_L1N_T0_34)
/IO_T11: J5.25, R92.2, U10.T11 (IO_L1P_T0_34)
/IO_T12: J4.3, U10.T12 (IO_L2P_T0_34)
/IO_T14: J5.26, R93.2, U10.T14 (IO_L5P_T0_34)
/IO_T15: J6.5, U10.T15 (IO_L5N_T0_34)
/IO_T16: J6.21, U10.T16 (IO_L9P_T1_DQS_34)
/IO_T17: J4.11, U10.T17 (IO_L20P_T3_34)
/IO_T19: J4.16, U10.T19 (IO_25_34)
/IO_U12: J4.4, U10.U12 (IO_L2N_T0_34)
/IO_U13: J4.5, R94.1, U10.U13 (IO_L3P_T0_DQS_PUDC_B_34)
/IO_U14: J4.8, U10.U14 (IO_L11P_T1_SRCC_34)
/IO_U15: J4.13, U10.U15 (IO_L11N_T1_SRCC_34)
/IO_U17: J4.14, U10.U17 (IO_L9N_T1_DQS_34)
/IO_V13: J4.6, U10.V13 (IO_L3N_T0_DQS_34)
/IO_V16: J3.9, U10.V16 (IO_L18P_T2_34)
/IO_V17: J4.9, U10.V17 (IO_L21P_T3_DQS_34)
/IO_V18: J4.12, U10.V18 (IO_L21N_T3_DQS_34)
/IO_V20: J8.14, U10.V20 (IO_L16P_T2_34)
/IO_W16: J4.7, U10.W16 (IO_L18N_T2_34)
/IO_W20: J8.20, U10.W20 (IO_L16N_T2_34)
/MIO_0: R81.1, R146.1, U10.E6 (PS_MIO0_500)
/MIO_1: R88.2, TP25.1, U10.A7 (PS_MIO1_500), U12.1 (~CS)
/MIO_2: R79.1, TP32.1, U10.B8 (PS_MIO2_500), U12.5 (SI/IO0)
/MIO_3: R80.1, TP33.1, U10.D6 (PS_MIO3_500), U12.2 (SO/IO1)
/MIO_4: R86.1, TP34.1, U10.B7 (PS_MIO4_500), U12.3 (~WP/IO2)
/MIO_5: R85.1, TP35.1, U10.A6 (PS_MIO5_500), U12.7 (~HOLD/IO3)
/MIO_6: R84.1, TP28.1, U10.A5 (PS_MIO6_500), U12.6 (SCK)
/MIO_7: R83.1, R147.1, U10.D8 (PS_MIO7_500)
/MIO_8: R82.1, R148.1, U10.D5 (PS_MIO8_500)
/MIO_9: R87.1, TP31.1, U10.B5 (PS_MIO9_500), U11.K5 (RST#)
/MIO_10: TP26.1, U10.E9 (PS_MIO10_500), U11.A3 (DAT0)
/MIO_11: TP22.1, U10.C6 (PS_MIO11_500), U11.M5 (CMD)
/MIO_12: R89.2, TP24.1, U10.D9 (PS_MIO12_500)
/MIO_13: TP27.1, U10.E8 (PS_MIO13_500), U11.A4 (DAT1)
/MIO_14: TP29.1, U10.C5 (PS_MIO14_500), U11.A5 (DAT2)
/MIO_15: TP30.1, U10.C8 (PS_MIO15_500), U11.B2 (DAT3)
/MIO_16: U10.A19 (PS_MIO16_501), U13.40 (GTXCLK)
/MIO_17: U10.E14 (PS_MIO17_501), U13.39 (TXD0)
/MIO_18: U10.B18 (PS_MIO18_501), U13.38 (TXD1)
/MIO_19: U10.D10 (PS_MIO19_501), U13.37 (TXD2)
/MIO_20: U10.A17 (PS_MIO20_501), U13.36 (TXD3)
/MIO_21: U10.F14 (PS_MIO21_501), U13.35 (TX_EN)
/MIO_22: U10.B17 (PS_MIO22_501), U13.33 (RXC)
/MIO_23: R95.1, U10.D11 (PS_MIO23_501)
/MIO_24: R96.1, U10.A16 (PS_MIO24_501)
/MIO_25: R97.1, U10.F15 (PS_MIO25_501)
/MIO_26: R98.1, U10.A15 (PS_MIO26_501)
/MIO_27: U10.D13 (PS_MIO27_501), U13.26 (RX_DV)
/MIO_28: U10.C16 (PS_MIO28_501), U14.11 (DATA4)
/MIO_29: U10.C13 (PS_MIO29_501), U14.19 (DIR)
/MIO_30: U10.C15 (PS_MIO30_501), U14.20 (STP)
/MIO_31: U10.E16 (PS_MIO31_501), U14.18 (NXT)
/MIO_32: U10.A14 (PS_MIO32_501), U14.16 (DATA0)
/MIO_33: U10.D15 (PS_MIO33_501), U14.15 (DATA1)
/MIO_34: U10.A12 (PS_MIO34_501), U14.14 (DATA2)
/MIO_35: U10.F12 (PS_MIO35_501), U14.13 (DATA3)
/MIO_36: R142.2, U10.A11 (PS_MIO36_501), U14.12 (CLKOUT)
/MIO_37: U10.A10 (PS_MIO37_501), U14.10 (DATA5)
/MIO_38: U10.E13 (PS_MIO38_501), U14.9 (DATA6)
/MIO_39: U10.C18 (PS_MIO39_501), U14.8 (DATA7)
/MIO_40: R139.2, TP39.1, U10.D14 (PS_MIO40_501)
/MIO_41: TP41.1, U10.C17 (PS_MIO41_501), U15.4 (CMDA)
/MIO_42: TP45.1, U10.E12 (PS_MIO42_501), U15.6 (DAT0A)
/MIO_43: TP44.1, U10.A9 (PS_MIO43_501), U15.7 (DAT1A)
/MIO_44: TP43.1, U10.F13 (PS_MIO44_501), U15.1 (DAT2A)
/MIO_45: TP42.1, U10.B15 (PS_MIO45_501), U15.3 (DAT3A)
/MIO_46: J12.9 (DET_B), J13.9 (DET_B), R138.2, TP47.1, U10.D16 (PS_MIO46_501)
/MIO_47: R137.2, TP49.1, U10.B14 (PS_MIO47_501), U14.22 (RESETB)
/MIO_48: R144.2, U10.B12 (PS_MIO48_501), U16.3 (A1)
/MIO_49: R140.2, U10.C12 (PS_MIO49_501), U16.4 (A2)
/MIO_50: R145.2, U10.B13 (PS_MIO50_501), U17.3 (A1)
/MIO_51: R141.2, U10.B9 (PS_MIO51_501), U17.4 (A2)
/MIO_52: U10.C10 (PS_MIO52_501), U13.48 (MDC)
/MIO_53: U10.C11 (PS_MIO53_501), U13.47 (MDIO)
/MIO_VP: J9.2, U10.K9 (VP_0)
/MIO_VREF: C164.1, R101.2, R102.1, U10.E11 (PS_MIO_VREF_501)
/MISC_CFGBVS: R44.2, U10.M6 (CFGBVS_0)
/MISC_CLK: R45.2, U10.E7 (PS_CLK_500)
/MISC_DONE: R47.2, U10.R11 (DONE_0)
/MISC_DXN: R51.2, U10.M10 (DXN_0)
/MISC_DXP: R52.2, U10.M9 (DXP_0)
/MISC_INITB: R46.2, U10.R10 (INIT_B_0)
/MISC_PROGRAM: R43.2, U10.L6 (PROGRAM_B_0)
/MISC_SRST: R35.2, TP18.1, U7.3 (A1), U10.B10 (PS_SRST_B_501)
/MISC_TCK: J2.6, R42.2, U10.F9 (TCK_0)
/MISC_TDI: J2.10, R38.2, U10.G6 (TDI_0)
/MISC_TDO: J2.8, R39.2, U10.F6 (TDO_0)
/MISC_TMS: J2.4, R41.2, U10.J6 (TMS_0)
/POWER_1V5_PREFILT: C22.1, FB10.2, L1.2, R2.2, R16.2, U1.14 (VOS)
/POWER_1V5_SW: L1.1, U1.1 (SW@1), U1.2 (SW@2), U1.3 (SW@3)
/POWER_1V8_PREFILT: C24.1, FB13.2, L2.2, R4.2, R18.2, U2.14 (VOS)
/POWER_1V8_SW: L2.1, U2.1 (SW@1), U2.2 (SW@2), U2.3 (SW@3)
/POWER_1V_PREFILT: C27.1, FB14.2, L5.2, R10.2, R24.2, U5.14 (VOS)
/POWER_1V_SW: L5.1, U5.1 (SW@1), U5.2 (SW@2), U5.3 (SW@3)
/POWER_2V5_PREFILT: C25.1, FB11.2, L3.2, R6.2, R20.2, U3.14 (VOS)
/POWER_2V5_SW: L3.1, U3.1 (SW@1), U3.2 (SW@2), U3.3 (SW@3)
/POWER_3V3_PREFILT: C26.1, FB12.2, L4.2, R8.2, R22.2, U4.14 (VOS)
/POWER_3V3_SW: L4.1, U4.1 (SW@1), U4.2 (SW@2), U4.3 (SW@3)
/POWER_5V_1V5_FILT: C1.1, C6.1, FB2.1, U1.10 (AVIN), U1.11 (PVIN@1), U1.12 (PVIN@2)
/POWER_5V_1V8_FILT: C2.1, C7.1, FB4.1, U2.10 (AVIN), U2.11 (PVIN@1), U2.12 (PVIN@2)
/POWER_5V_1V_FILT: C5.1, C10.1, FB5.1, R1.1, U5.10 (AVIN), U5.11 (PVIN@1), U5.12 (PVIN@2)
/POWER_5V_2V5_FILT: C3.1, C8.1, FB3.1, U3.10 (AVIN), U3.11 (PVIN@1), U3.12 (PVIN@2)
/POWER_5V_3V3_FILT: C4.1, C9.1, FB1.1, U4.10 (AVIN), U4.11 (PVIN@1), U4.12 (PVIN@2)
/POWER_5V_DISPLAY: C187.1, C188.1, J8.4, R112.2
/POWER_ETH: C163.1, C165.1, C166.1, C167.1, C168.1, FB15.1, U13.9 (XTALVDD), U13.12 (BIASVDD), U13.16 (AVDD1), U13.22 (AVDD2)
/POWER_ETH_A: C174.1, C178.1, C182.1, FB16.1, U13.13 (AVDDL1), U13.19 (AVDDL2), U13.25 (AVDDL3)
/POWER_ETH_GND: C186.2, J7.SH, R113.2, R124.2, R125.2, R126.2
/POWER_ETH_PLL: C175.1, C179.1, FB17.1, U13.11 (PLLVDD)
/POWER_ETH_REGOUT: C173.1, C177.1, C183.1, FB16.2, FB17.2, U13.2 (DVDD1), U13.3 (REGOUT), U13.30 (DVDD2)
/POWER_I2C_SEL: C207.1, R153.1, R157.1, R158.2, R160.1, R161.2
/POWER_I2C_SEL_R: R153.2, U17.7 (VREF_B), U17.8 (EN)
/POWER_IN: F1.1, J1.1
/POWER_IN_FUSED: F1.2, FB6.2
/POWER_SRST_R: R36.2, U7.7 (VREF_B), U7.8 (EN)
/POWER_UART_SEL: C206.1, R151.2, R152.1, R155.2, R156.1, R159.1
/POWER_UART_SEL_R: R152.2, U16.7 (VREF_B), U16.8 (EN)
/POWER_USB_VBUS: F2.1, J14.A4 (VBUS), J14.A9 (VBUS), J14.B4 (VBUS), J14.B9 (VBUS), TP51.1
/POWER_USB_VBUS_FILT: D21.2 (A), FB18.2, R163.2, U19.6 (OUT), U19.8 (OUT)
/POWER_USB_VBUS_FUSED: C216.1, C217.1, F2.2, FB18.1
/POWER_USB_VBUS_PHY: R163.1, U14.2 (VBUS)
/SOC_POWER_ADC: C55.1, C62.1, FB9.1, U10.J9 (VCCADC_0)
/SOC_POWER_ADCGND: FB7.1, R12.2, R13.2, R14.2, U10.J10 (GNDADC_0)
/SOC_POWER_BATT: R15.1, U10.F11 (VCCBATT_0)
/SOC_POWER_PLL: C63.1, C75.1, FB8.1, U10.G8 (VCCPLL)
/SOC_POWER_REFN: R13.1, U10.K10 (VREFN_0)
/SOC_POWER_REFP: R12.1, U10.L9 (VREFP_0)
/SOC_POWER_VN: R14.1, U10.L10 (VN_0)
/USB_DN: D22.4 (D3), D22.7 (D3), J14.A7 (D-), J14.B7 (D-), U14.5 (DM)
/USB_DP: D22.5 (D4), D22.6 (D4), J14.A6 (D+), J14.B6 (D+), U14.6 (DP)
/USB_ID: D22.1 (D1), D22.2 (D2), D22.9 (D2), D22.10 (D1), J14.A5 (CC1), J14.B5 (CC2), U14.1 (ID)
GND: BT1.2 (-), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2, C64.2, C65.2, C66.2, C67.2, C68.2, C69.2, C70.2, C71.2, C72.2, C73.2, C74.2, C75.2, C76.2, C77.2, C78.2, C79.2, C80.2, C81.2, C82.2, C83.2, C84.2, C85.2, C86.2, C87.2, C88.2, C89.2, C90.2, C91.2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
unnamed: BT1.1 (+), D17.1 (K), U18.3 (VBAT)
unnamed: C180.1, TR1.1 (CT)
unnamed: C181.1, TR1.4 (CT)
unnamed: C184.1, TR1.7 (CT)
unnamed: C185.1, TR1.10 (CT)
unnamed: C186.1, R108.1, R109.1, R110.1, R111.1
unnamed: D3.2 (A), R26.1
unnamed: D4.2 (A), R27.1
unnamed: D5.2 (A), R28.1
unnamed: D6.2 (A), R29.1
unnamed: D7.2 (A), R46.1
unnamed: D8.2 (A), R47.1
unnamed: D9.2 (A), R90.1
unnamed: D10.2 (A), R91.1
unnamed: D11.2 (A), R92.1
unnamed: D12.2 (A), R93.1
unnamed: D16.1 (K), R107.1
unnamed: D17.2 (A), R149.1
unnamed: D18.2 (A), R146.2
unnamed: D19.2 (A), R147.2
unnamed: D20.2 (A), R148.2
unnamed: D23.1 (K), R162.1
unnamed: J2.14, R40.2, U7.6 (B1)
unnamed: J7.9, R104.1
unnamed: J7.12, R106.1
unnamed: J10.1, R159.2, U16.5 (B2)
unnamed: J10.3, R156.2, U16.6 (B1)
unnamed: J12.5 (CLK), U15.19 (CLK_{B0})
unnamed: J12.3 (CMD), U15.20 (CMD_{B0})
unnamed: J12.7 (DAT0), U15.18 (DAT0_{B0})
unnamed: J12.8 (DAT1), U15.16 (DAT1_{B0})
unnamed: J12.1 (DAT2), U15.23 (DAT2_{B0})
unnamed: J12.2 (DAT3/CD), U15.22 (DAT3_{B0})
unnamed: J13.5 (CLK), U15.13 (CLK_{B1})
unnamed: J13.3 (CMD), U15.12 (CMD_{B1})
unnamed: J13.7 (DAT0), U15.14 (DAT0_{B1})
unnamed: J13.8 (DAT1), U15.15 (DAT1_{B1})
unnamed: J13.1 (DAT2), U15.8 (DAT2_{B1})
unnamed: J13.2 (DAT3/CD), U15.10 (DAT3_{B1})
unnamed: R108.2, TR1.15 (CT)
unnamed: R109.2, TR1.18 (CT)
unnamed: R110.2, TR1.21 (CT)
unnamed: R111.2, TR1.24 (CT)
unnamed: R85.2, SW2.2 (B)
unnamed: R86.2, SW3.2 (B)
unnamed: R143.1, SW4.2 (B)
unnamed: R18.1, R19.2, TP6.1, U1.13 (EN), U2.4 (PG)
unnamed: R2.1, R3.2, U1.5 (FB)
unnamed: R16.1, R17.2, TP2.1, U1.4 (PG), U3.13 (EN)
unnamed: C11.1, U1.9 (SS/TR)
unnamed: R24.1, R25.2, TP3.1, U2.13 (EN), U5.4 (PG)
unnamed: R4.1, R5.2, U2.5 (FB)
unnamed: C12.1, U2.9 (SS/TR)
unnamed: R6.1, R7.2, U3.5 (FB)
unnamed: R20.1, R21.2, TP8.1, U3.4 (PG), U4.13 (EN)
unnamed: C13.1, U3.9 (SS/TR)
unnamed: R8.1, R9.2, U4.5 (FB)
unnamed: R22.1, R23.2, R26.2, R30.1, TP11.1, U4.4 (PG)
unnamed: C14.1, U4.9 (SS/TR)
unnamed: R1.2, U5.13 (EN)
unnamed: R10.1, R11.2, U5.5 (FB)
unnamed: C15.1, U5.9 (SS/TR)
unnamed: R33.1, U6.7 (EN)
unnamed: R34.1, TP15.1, U6.9 (PGOOD)
unnamed: R89.1, U11.M6 (CLK)
unnamed: C151.1, U11.C2 (VDDI)
unnamed: R107.2, U13.45 (LED1)
unnamed: R104.2, U13.44 (LED2)
unnamed: R105.1, R106.2, U13.43 (LED3)
unnamed: R103.1, U13.42 (LED4)
unnamed: R100.2, U13.41 (PHYA0)
unnamed: R99.2, U13.10 (RDAC)
unnamed: R95.2, U13.32 (RXD0)
unnamed: R96.2, U13.31 (RXD1)
unnamed: R97.2, U13.28 (RXD2)
unnamed: R98.2, U13.27 (RXD3)
unnamed: C161.1, U13.8 (XTALI), Y2.1
unnamed: C162.1, TP38.1, U13.7 (XTALO), Y2.3
unnamed: U14.7 (CPEN), U19.1 (EN)
unnamed: R154.2, U14.24 (RBIAS)
unnamed: TP50.1, U14.23 (REFCLK), Y4.3 (OUT)
unnamed: R139.1, U15.9 (CLKA)
unnamed: R143.2, U15.24 (SEL)
unnamed: U18.1 (X1), Y3.1
unnamed: U18.2 (X2), Y3.2
unnamed: R162.2, U19.2 (FLG)
unnamed: R45.1, TP19.1, Y1.3 (OUT)
unnamed: R37.2, Y1.1 (Tri-State)
unnamed: R150.2, Y4.1 (Tri-State)
POR: C89.1, R30.2, SW1.1, TP14.1, U10.C7 (PS_POR_B_500), U13.46 (RESET)

Notes on the sheet:
JTAG
GIGABIT ETHERNET
FPGA STATUS LEDS
XADC
YELLOW
DDR
CLK
POWER REGULATORS
SOC POWER IN
FPGA LEDS
MIO LEDS
EMMC+BOOTSTRAP
SD CARDS
GREEN
I2C
RTC
USB
FPGA IO HEADERS
According to B50612 DS: (default led functions, may be programmed) ETH_LED1 indicates link speed, 0(glowing) - 1gbit/10mbit, 1(not glowing) - 100mbit/no link
QSPI FLASH
ZYNQ SOC
UART
DISPLAY
